<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x65e0;&#x7eBF;&#x6A21;&#x5757;&#x63A5;&#x53D7;&#xFF08;IO&#x6A21;&#x62DF;&#xFF09;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


